# IAR project Car.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\User; ..\Fire; ..\Library; ..\Library\Kinetis; ..\Library\IAR; ..\Library\CMSIS\Inc; ..\Library\USB; ..\Library\FatFs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Car.hex
  ILINK.IlinkOutputFile: Car.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Fire
    ../Fire/: VCAN_ASCII.c VCAN_ASCII.h VCAN_camera.c VCAN_camera.h VCAN_computer.c VCAN_computer.h VCAN_key.c VCAN_key.h VCAN_key_event.c VCAN_key_event.h VCAN_LCD.c VCAN_LCD.h VCAN_LCD_ST7735R.c VCAN_LCD_ST7735R.h VCAN_LED.C VCAN_LED.H VCAN_MMA7455.c VCAN_MMA7455.h VCAN_NRF24L0.c VCAN_NRF24L0.h VCAN_NRF24L0_MSG.c VCAN_NRF24L0_MSG.h VCAN_OV7725_Eagle.c VCAN_OV7725_Eagle.h VCAN_OV7725_REG.h VCAN_RTC_count.C VCAN_RTC_count.h VCAN_SCCB.c VCAN_SCCB.h VCAN_UI_VAR.c VCAN_UI_VAR.h
  group Library
    ../Library/: common.h misc.c misc.h MK60_adc.c MK60_adc.h MK60_can.c MK60_can.h MK60_dac.c MK60_dac.h MK60_dma.c MK60_dma.h MK60_DWT.c MK60_DWT.h MK60_flash.c MK60_flash.h MK60_flexbus.c MK60_flexbus.h MK60_ftm.c MK60_FTM.h MK60_gpio.c MK60_gpio.h MK60_gpio_cfg.h MK60_i2c.c MK60_i2c.h MK60_lptmr.c MK60_lptmr.h MK60_mcg.c MK60_mcg.h MK60_PIT.c MK60_pit.h MK60_port.c MK60_port.h MK60_rtc.c MK60_rtc.h MK60_sdhc.c MK60_sdhc.h MK60_spi.c MK60_spi.h MK60_SysTick.c MK60_SysTick.h MK60_uart.c MK60_uart.h MK60_wdog.c MK60_wdog.h vectors.c vectors.h
    ../Library/IAR/: iar.h startup_MK60DZ10.s system_MK60DZ10.c system_MK60DZ10.h
  group Library/CMSIS/Include
    ../Library/CMSIS/Inc/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group Library/Kinetis
    ../Library/kinetis/: MK10DZ10.h MK20DZ10.h MK30DZ10.h MK40DZ10.h MK50DZ10.h MK51DZ10.h MK52DZ10.h MK53DZ10.h MK60DZ10.h MK60F12.h MK60F15.h MK61F12.h MK61F15.h MK70F12.h MK70F15.h
  group User
    ../User/: Bluetooth.c Bluetooth.h include.h main.c MK60_conf.c MK60_conf.h MK60_it.c MK60_it.h OV7725.c OV7725.h PID.c PID.h port.h PORT_cfg.h SD5.c SD5.h Speed.c Speed.h
