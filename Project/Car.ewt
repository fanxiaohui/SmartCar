<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Fire</name>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_ASCII.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_ASCII.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_camera.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_camera.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_computer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_computer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_key.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_key_event.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_key_event.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_LCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_LCD.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_LCD_ST7735R.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_LCD_ST7735R.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_LED.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_LED.H</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_MMA7455.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_MMA7455.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_NRF24L0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_NRF24L0.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_NRF24L0_MSG.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_NRF24L0_MSG.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_OV7725_Eagle.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_OV7725_Eagle.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_OV7725_REG.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_RTC_count.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_RTC_count.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_SCCB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_SCCB.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_UI_VAR.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fire\VCAN_UI_VAR.h</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <group>
      <name>CMSIS</name>
      <group>
        <name>Include</name>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\arm_common_tables.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\arm_const_structs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\arm_math.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\core_cm0.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\core_cm0plus.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\core_cm3.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\core_cm4.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\core_cm4_simd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\core_cmFunc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\core_cmInstr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\core_sc000.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Inc\core_sc300.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>Kinetis</name>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK10DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK20DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK30DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK40DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK50DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK51DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK52DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK53DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK60DZ10.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK60F12.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK60F15.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK61F12.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK61F15.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK70F12.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\kinetis\MK70F15.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Library\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\IAR\iar.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\misc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_can.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_dac.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_DWT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_DWT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_flexbus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_flexbus.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_FTM.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_gpio_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_lptmr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_mcg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_pit.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_port.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_rtc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_sdhc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_sdhc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_SysTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_SysTick.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_wdog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MK60_wdog.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\IAR\startup_MK60DZ10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\IAR\system_MK60DZ10.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\IAR\system_MK60DZ10.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\vectors.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\vectors.h</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\User\Bluetooth.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Bluetooth.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\MK60_conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\MK60_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\MK60_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\MK60_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\OV7725.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\OV7725.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\PID.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\PID.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\port.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\PORT_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\SD5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\SD5.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Speed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Speed.h</name>
    </file>
  </group>
</project>


